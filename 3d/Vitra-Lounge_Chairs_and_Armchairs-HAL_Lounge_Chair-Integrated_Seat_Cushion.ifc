Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-10-25T14:53:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 25 14:53:59 2021 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{E463DFCE-5891-4251-B050-453731E20362}\ifc * Database version: 5507 * Database creation date: Mon Oct 25 14:53:58 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 25 14:53:58 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 25 14:53:58 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: HAL Lounge Chair with integrated seat cushion, Vitra-Lounge_Chairs_and_Armchairs-HAL_Lounge_Chair-Integrated_Seat_Cushion:HAL Lounge Chair with integrated seat cushion:435832
In: Level 1
Type - Material: Cream, Basic Dark, Natural oak with protective vanish
Type - Dimensions - NominalDepth: 828.036 mm; NominalHeight: 1047.2 mm; NominalLength: 722.864 mm
Type - General - BIMObjectName: Vitra-Lounge_Chairs_and_Armchairs-HAL_Lounge_Chair-Integrated_Seat_Cushion; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Dining chairs; Uniclass2015Reference: Pr_40_50_12_22; Version: 1; VersionDate: 20/10/2021
Type - Identity Data - Collection: HAL Lounge; Cost: 0; Designer: Jasper Morrison; Manufacturer: Vitra; Model: HAL Lounge Chair with integrated seat cushion; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; Type Name: HAL Lounge Chair with integrated seat cushion; URL: https://www.vitra.com/en-un/living/product/details/hal-lounge-chair
Type - Other - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Chairs; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Lounge_Chairs_and_Armchairs-HAL_Lounge_Chair-Integrated_Seat_Cushion; Features: n/a; Finish: n/a; Grade: n/a; Material: n/a; ModelNumber: n/a; ModelReference: 44048100; Name: HAL_Lounge_Chair-Integrated_Seat_Cushion; ReplacementCost: n/a; Shape: Sculptured; Size: 730x830x1050 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 44048100; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 2.22266 m2; Volume: 0.626811 m3
Materials and Finishes - BaseMaterial: Natural oak with protective vanish; CoverMaterial: Cream
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Vitra-Lounge_Chairs_and_Armchairs-HAL_Lounge_Chair-Integrated_Seat_Cushion: HAL Lounge Chair with integrated seat cushion; Family and Type: Vitra-Lounge_Chairs_and_Armchairs-HAL_Lounge_Chair-Integrated_Seat_Cushion: HAL Lounge Chair with integrated seat cushion; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Lounge_Chairs_and_Armchairs-HAL_Lounge_Chair-Integrated_Seat_Cushion: HAL Lounge Chair with integrated seat cushion; Type Id: Vitra-Lounge_Chairs_and_Armchairs-HAL_Lounge_Chair-Integrated_Seat_Cushion: HAL Lounge Chair with integrated seat cushion; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
